# Keil uVision project DNZ_fly.uvprojx, settings and files
target DNZ_fly (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DNZ_fly +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\SYSTEM;..\HARDWARE\AK8975;..\HARDWARE\MPU6050;..\HARDWARE\SOFT_IIC;..\HARDWARE\TIMER;..\MATH;..\HAL;..\HARDWARE\INTERRUPT;..\HARDWARE\RC;..\USB\CONFIG;..\USB\STM32_USB-FS-Device_Driver\inc;..\USB\CONFIG;..\HARDWARE\ST_FLASH;..\HARDWARE\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/AK8975/: AK8975.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/SOFT_IIC/: softiic.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/INTERRUPT/: interrupt.c
    ../HARDWARE/RC/: rc_process.c
    ../HARDWARE/ST_FLASH/: stflash.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/: stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_exti.c
  group README
    ../: README.TXT
  group MATH
    ../MATH/: kalman.c IMU.c filter.c maths.c
  group HAL
    ../HAL/: data_process.c ANO_USART.c scheduler.c control.c pid.c
  group USB
    ../USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usbio.c
    ../USB/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
